# Keil uVision project Capture.uvproj, settings and files
target Timer2_Capture (MCS-51)
  device: MS51EC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: Capture +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: Capture.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
