# Keil uVision project ROM_Const_One.uvproj, settings and files
target Const (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ROM_const_One +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: ROM_Const_One.C
  group Common
    ../../../../Library/StdDriver/src/: uart.c sys.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
