# Keil uVision project UART4.uvproj, settings and files
target GPIO (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: uart2 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: UART4_TX_RX.c
  group Library
    ../../../../Library/StdDriver/src/: delay.c sys.c uart4.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
