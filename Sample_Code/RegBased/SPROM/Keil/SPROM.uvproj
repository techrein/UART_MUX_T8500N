# Keil uVision project SPROM.uvproj, settings and files
target Const (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: SPROM +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex 0x0 0x1000 0xFF80 0x80
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: main.C ProtectBit.C SPROM.C
  group Common
    ../../../../Library/StdDriver/src/: sys.c uart.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
