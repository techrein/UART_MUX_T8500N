# Keil uVision project UART2.uvproj, settings and files
target GPIO (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: uart2 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: UART2_TX_RX.c
  group Library
    ../../../../Library/StdDriver/src/: delay.c uart2.c sys.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
