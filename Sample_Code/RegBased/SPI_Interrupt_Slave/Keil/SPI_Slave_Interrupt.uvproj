# Keil uVision project SPI_Slave_Interrupt.uvproj, settings and files
target SPI_INT_S (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: Master_P +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: SPI_Slave_Int.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
