# Keil uVision project UART1.uvproj, settings and files
target UART_mode_1 (MCS-51)
  device: MS51EC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: UART1 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: UART1_P02GPIO.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c uart.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
