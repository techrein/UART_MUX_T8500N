# Keil uVision project SPI_Master_Interrupt.uvproj, settings and files
target SPI_INT_M (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Master_P +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: SPI_Master_Int.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c delay.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
