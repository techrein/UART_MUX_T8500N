# Keil uVision project Timer0_m1.uvproj, settings and files
target Timer01_M0 (MCS-51)
  device: MS51EC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: Timer0_M1 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: Timer0_M1.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
